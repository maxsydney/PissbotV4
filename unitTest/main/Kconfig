## unitTest/main/Kconfig
```kconfig
menu "Unit Test"

menuconfig IS_UNIT_TEST
	bool "Is unit test"
	default y

endmenu
```
